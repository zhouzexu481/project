# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\User;.\Library;.\freertos\inc;.\freertos\port;.\freertos\src;.\freertos;.\system;.\Tasks;.\Output;.\Input
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group freertos/inc
    ./freertos/: FreeRTOSConfig.h
    ./freertos/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freertos/port
    ./freertos/port/: heap_4.c port.c
  group freertos/src
    ./freertos/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group system
    ./system/: sys.c sys.h Delay.c Delay.h Key.c Key.h OLED.c OLED.h OLED_Font.h serial.c serial.h
  group Input
    ./Input/: AD.c AD.h MQ2.c MQ2.h MyI2C1.c MyI2C1.h AHT20.c AHT20.h AHT20_Reg.h MyI2C2.c MyI2C2.h BH1750.c BH1750.h BH1750_Reg.h
  group Output
    ./Output/: Buzzer.c Buzzer.h PWM_Motor.c PWM_Motor.h PWM_LED.c PWM_LED.h PWM_WaterPump.c PWM_WaterPump.h
  group Tasks
    ./Tasks/: config.h task_manager.c task_manager.h sensor_task.c sensor_task.h control_task.c control_task.h display_task.c display_task.h comm_task.c comm_task.h
